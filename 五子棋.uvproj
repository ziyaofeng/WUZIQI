# Keil uVision project 五子棋.uvproj, settings and files
target stc12c5a60s2 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 五子棋 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Include
  link misc: RECURSIONS (100)
  group Driver
    ./Driver/: HX8347D.c Touch.c W25Qxx.c
  group Game
    ./Game/: sys_app.c wzq.c wzq_lib.c
